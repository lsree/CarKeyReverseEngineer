options:
  parameters:
    author: locch
    generate_options: qt_gui
    id: untitled
    output_language: python
    title: Not titled yet
  states: {}

blocks:
- name: samp_rate
  id: variable
  parameters:
    value: '32000'
  states: {}
- name: analog_dpll_bb_0
  id: analog_dpll_bb
  parameters:
    period: '400'
  states: {state: disabled}
- name: blocks_burst_tagger_0
  id: blocks_burst_tagger
  parameters:
    false_key: burst
    false_value: 'False'
    true_key: burst
    true_value: 'True'
    type: complex
  states: {state: disabled}
- name: blocks_file_sink_0
  id: blocks_file_sink
  parameters:
    file: /home/locch/Documents/SDR/Car_Reverse_Eng/open_press3
    type: complex
  states: {}
- name: blocks_file_sink_0_0
  id: blocks_file_sink
  parameters:
    file: /home/locch/Documents/SDR/Car_Reverse_Eng/open_press_int
    type: complex
  states: {}
- name: blocks_integrate_xx_0
  id: blocks_integrate_xx
  parameters:
    decim: '400'
    type: complex
  states: {}
- name: blocks_peak_detector2_fb_0
  id: blocks_peak_detector2_fb
  parameters:
    alpha: '0.001'
    look_ahead: '1000'
    threshold_factor_rise: '7'
  states: {state: disabled}
- name: qtgui_sink_x_0
  id: qtgui_sink_x
  parameters:
    bw: samp_rate
    fc: 315e6
    fftsize: '1024'
    type: complex
    wintype: firdes.WIN_BLACKMAN_hARRIS
  states: {}
- name: qtgui_sink_x_0_0
  id: qtgui_sink_x
  parameters:
    bw: samp_rate
    fc: 315e6
    fftsize: '1024'
    type: complex
    wintype: firdes.WIN_BLACKMAN_hARRIS
  states: {}
- name: rtlsdr_source_0
  id: rtlsdr_source
  parameters:
    bb_gain0: '20'
    freq0: 315e6
    gain0: '10'
    gain_mode0: 'False'
    if_gain0: '20'
    sample_rate: samp_rate
    sync: sync
    type: fc32
  states: {}

connections:
- [analog_dpll_bb_0, '0', blocks_burst_tagger_0, '0']
- [analog_dpll_bb_0, '0', blocks_burst_tagger_0, '1']
- [blocks_integrate_xx_0, '0', blocks_file_sink_0_0, '0']
- [blocks_integrate_xx_0, '0', qtgui_sink_x_0_0, '0']
- [rtlsdr_source_0, '0', analog_dpll_bb_0, '0']
- [rtlsdr_source_0, '0', blocks_file_sink_0, '0']
- [rtlsdr_source_0, '0', blocks_integrate_xx_0, '0']
- [rtlsdr_source_0, '0', qtgui_sink_x_0, '0']

metadata:
  file_format: 1
