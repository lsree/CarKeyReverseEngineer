options:
  parameters:
    author: locch
    generate_options: qt_gui
    id: untitled
    output_language: python
    title: Car_RemoteRx
  states: {}

blocks:
- name: LO_Freq
  id: variable
  parameters:
    value: '315000000'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: '1000000'
  states: {}
- name: blocks_complex_to_mag_0
  id: blocks_complex_to_mag
  parameters: {}
  states: {}
- name: blocks_complex_to_mag_squared_0
  id: blocks_complex_to_mag_squared
  parameters: {}
  states: {state: disabled}
- name: blocks_file_sink_0
  id: blocks_file_sink
  parameters:
    file: /home/locchanan/Documents/RF_Projects/CarKeyReverseEngineer/open_press.smpl
    type: complex
  states: {state: disabled}
- name: blocks_file_sink_0_0
  id: blocks_file_sink
  parameters:
    file: /home/locchanan/Documents/RF_Projects/CarKeyReverseEngineer/open_press_mag.smpl
    type: float
  states: {}
- name: iio_fmcomms2_source_0
  id: iio_fmcomms2_source
  parameters:
    auto_filter: 'True'
    bandwidth: '20000000'
    bbdc: 'False'
    buffer_size: '32768'
    frequency: LO_Freq
    gain1: '''manual'''
    manual_gain1: '64'
    quadrature: 'False'
    rf_port_select: '''A_BALANCED'''
    rfdc: 'False'
    rx1_en: 'True'
    rx2_en: 'False'
    samplerate: samp_rate
    uri: ip:192.168.0.6
  states: {}
- name: qtgui_sink_x_0
  id: qtgui_sink_x
  parameters:
    bw: '20000000'
    fc: LO_Freq
    fftsize: '1024'
    type: complex
    wintype: firdes.WIN_BLACKMAN_hARRIS
  states: {state: disabled}
- name: qtgui_sink_x_0_0
  id: qtgui_sink_x
  parameters:
    bw: '20000000'
    fc: LO_Freq
    fftsize: '1024'
    type: float
    wintype: firdes.WIN_BLACKMAN_hARRIS
  states: {}

connections:
- [blocks_complex_to_mag_0, '0', blocks_file_sink_0_0, '0']
- [blocks_complex_to_mag_0, '0', qtgui_sink_x_0_0, '0']
- [blocks_complex_to_mag_squared_0, '0', blocks_file_sink_0_0, '0']
- [blocks_complex_to_mag_squared_0, '0', qtgui_sink_x_0_0, '0']
- [iio_fmcomms2_source_0, '0', blocks_complex_to_mag_0, '0']
- [iio_fmcomms2_source_0, '0', blocks_complex_to_mag_squared_0, '0']
- [iio_fmcomms2_source_0, '0', blocks_file_sink_0, '0']
- [iio_fmcomms2_source_0, '0', qtgui_sink_x_0, '0']

metadata:
  file_format: 1
